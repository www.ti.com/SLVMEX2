# Altium PCB PMP41166A_Multi_Level_Totem Pole PFC.PcbDoc (part 4 of 5)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 5708.66 x 4330.71 mil, 6 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Signal Layer 3, Signal Layer 4, Bottom Layer), stack 65.8 mil thick; 226 components, 115 nets, 667 pads, 404 vias.

## Via types
v1: diameter 20, hole 10, Top Layer to Bottom Layer, 392 vias
v2: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, 12 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
5Vs: C129.1 C142.1 J302.4 U104.1 | length 3869.8
  Signal Layer 3 w25: v1(4130,1875) 4620.65,1875 ; 4621.22,1873.76 4657.5,1837.48 4657.5,1789.75 4854.75,1592.5 5051.83,1592.5 5108.13,1536.2 ; 5108.46,1536.54 5484.5,1160.5 5714.25,1160.5 6143.56,731.18 6328.56,731.18 6411.75,648 6610,648 6790,468 6882,468 J302.4@6950,400
  Bottom Layer w20: C142.1@4104.69,1780 C142.1@4106.34,1780
  Bottom Layer w25: U104.1@4065.43,1570 4145,1570 4160.87,1585.87 4160.87,1724.13 ; C142.1@4104.69,1780 4125,1800.32 C129.1@4125,1830 ; C142.1@4106.34,1780 4160.67,1725.67 ; C129.1@4130,1840 v1(4130,1875)
12V1: C122.2 C131.1 J303.1 U102.11 U102.16 | length 2273.1
  Top Layer w25: U102.16@6096.42,2151.42 6096.42,2121.69 6124.59,2093.52 6189.59,2093.52 6218.31,2064.8 6320.63,2064.8 6346.42,2090.59 U102.11@6346.42,2151.42 C122.2@6346.42,2218.58 ; C131.1@6252.72,2219.33 C131.1@6257.72,2219.33 C122.2@6344.33,2219.33 ; 6348.72,2091.28 6468.72,2091.28 7190,1370 7190,930 7160,900 J303.1@7050,900 J303.1@7045,905
12Vp: 12Vp.1 C119.1 C126.2 C127.1 C137.1 C148.1 J100.9 J303.4 R121.2 R132.2 U101.3 U106.1 U107.1 | length 14726.2
  Top Layer w40: U107.1@6331.67,348.33 6408.33,348.33 C127.1@6450,390
  Top Layer w50: C127.1@6439.41,373.5 6440,372.91 C126.2@6560,372.91 C126.2@6570,372.91 ; 12Vp.1@6570,270 C126.2@6570,365 ; C126.2@6600,380 C148.1@6700,380 ; C148.1@6710,380 6760,380 6790,410 6790,940 6847.48,997.48 6943.09,997.48 6950,1004.39 J303.4@6950,1005
  Signal Layer 2 w20: v1(2830,2420) 3151.01,2420 3181.01,2390 3230,2390 3277.01,2342.99 3277.24,2342.99 3300.24,2320 3490,2320 3508.46,2338.46 v1(3508.46,2437.09) ; v1(5270,990) 5160,1100 5160,1439.9 4998.54,1601.37 4998.54,1753.89 5001.05,1756.41 5001.05,2409.17 5146.81,2554.92 5146.81,3473.27 5415.96,3742.42 5572.61,3742.42 v1@5637.93,3807.74
  Signal Layer 2 w25: v1(5655,755) 5655,695 5820,530 ; 5825,525 6020.48,329.52 6335.48,329.52 6395,270 12Vp.1@6570,270 6570,500 6552,518 6406.75,518 6330,594.75 6330,1066.56 6579,1315.56 6579,2265.75 6390,2454.75 v1(6390,2530)
  Signal Layer 3 w20: v1@3508.46,2440 3706.77,2440 3803,2343.77 3803,1727 3886,1644 4411,1644 4415,1640 ; 4415.18,1640.18 4621.09,1434.28 4621.09,1375.28 4844.87,1151.5 4864.87,1151.5 5139.37,877 5140.18,877 5156,861.18 5156,765
  Signal Layer 3 w25: 5158.5,763.22 5260,661.72 5260,660 6251.72,660 6416.72,495 6535,495 6570,460 12Vp.1@6570,270 ; v1(5270,990) 5410,850 5560,850 v1(5655,755)
  Bottom Layer w20: R132.2@2800,2390 v1(2830,2420) ; C119.1@3380,2330 3380,2400 3417.09,2437.09 U101.3@3467.52,2437.09 v1(3508.46,2437.09)
  Bottom Layer w25: C137.1@6340,2530 C137.1@6351.5,2530 ; U106.1@6363.58,2600.16 6363.58,2542.09 C137.1@6351.5,2530 ; R121.2@6373.62,280 6374.31,279.31 6559.31,279.31 12Vp.1@6560,280 ; v1(6390,2530) C137.1@6351.5,2530
  other v1: 5640,3810
+BRDG_N: R108.1 U101.7 | length 1449.3
  Top Layer w20: v1(3210,2500) 3240,2500 3340,2600 3340,3670 3360,3690 3400,3690 v1(3440,3650)
  Bottom Layer w11.81: U101.7@3250,2487.07 U101.7@3252.95,2487.09
  Bottom Layer w20: v1(3210,2500) 3222.91,2487.09 U101.7@3252.95,2487.09 ; v1(3440,3650) R108.1@3440,3681.81
+BRDG_P: R116.1 U101.5 | length 1403.8
  Signal Layer 2 w20: v1(3300,2390) 3360,2450 3360,3420 3410,3470 v1(3600,3470)
  Bottom Layer w20: U101.5@3252.95,2387.09 3297.09,2387.09 v1(3300,2390) ; R116.1@3560,3470 v1(3600,3470)
AC_CUR_SENSE: R312.2 U100.6 | length 863.7
  Signal Layer 3 w20: v1(4085,1330) 4140,1330 4425,1045 4425,900 v1(4555,770)
  Bottom Layer w20: U100.6@4041.93,1330 v1(4085,1330) ; R312.2@4534.77,793.89 4534.77,787.67 4552.44,770 v1(4555,770)
ACL_SENSE: C314.1 J301.15 R18.1 R101.1 R329.2 | length 904.7
  Top Layer w20: C314.1@4551.17,545.35 R329.2@4587.71,545.35 ; R329.2@4593.62,542.85 4593.62,588.6 4610.75,605.73 4610.75,630.32
  Signal Layer 2 w20: v1(4274.84,1051.79) 4423.43,903.19 4423.43,693.68 v1@4572.03,545.09
  Bottom Layer w20: v1(4274.84,1051.79) R18.1@4274.84,1068.24 ; R101.1@4472.5,613.57 4481.9,604.17 4512.81,604.17 v1(4571.59,545.4)
ACN_SENSE: C313.1 J301.21 R16.1 R105.1 R328.2 | length 1342
  Top Layer w20: J301.21@4705.39,703.94 4705.39,590.32 4725.49,570.22 C313.1@4725.49,549.9 ; C313.1@4726.39,549.01 C313.1@4726.63,549.01 ; C313.1@4728.9,545.75 R328.2@4771.03,545.75
  Signal Layer 3 w20: v1(4358.3,1179.09) 4481.32,1056.07 4481.32,986.86 4748.51,719.67 v1@4748.51,547.19
  Bottom Layer w20: v1(4358.3,1179.09) 4381.86,1179.09 R16.1@4381.91,1179.04 ; R105.1@4483.64,418.84 4598.52,418.84 4724.71,545.03 v1@4751.51,545.03
  other v1: 4749.96,545.59
ACVOL_SENSE: C4.1 J301.12 R14.1 | length 479.2
  Top Layer w20: 4547.76,911.42 4547.76,930.93 4477.56,1001.12 4477.56,1114.8 4542.48,1179.72 v1(4653.49,1179.72)
  Bottom Layer w20: R14.1@4628.62,1180 4671.59,1180 C4.1@4672.29,1179.3
AINN: C105.1 C129.2 C142.2 J302.2 J302.3 L102.4 R109.2 R119.1 U104.4 | length 4554.8
  Top Layer w25: J302.3@7050,400 J302.3@7050,405
  Signal Layer 1 w25: J302.2@6950,300 J302.3@7050,400
  Signal Layer 2 w25: J302.2@6950,300 7045,395 J302.3@7045,400
  Signal Layer 3 w25: v1(4065,1890) 4082,1907 4633.91,1907 4690.77,1850.14 4690.77,1802.91 4864.84,1628.84 5066.87,1628.84 5076.08,1619.63 ; 5075.9,1619.45 5102.39,1592.96 ; 5102.22,1592.78 5502.5,1192.5 5727.5,1192.5 6156.82,763.18 6339.26,763.18 6339.78,762.66 ; 6341.06,763.94 6425,680 6625,680 6805,500 6950,500 J302.3@7050,400 J302.2@6950,300
  Bottom Layer w20: R109.2@3645,1715 3645,1695 3670,1670 R119.1@3861.38,1670 ; C105.1@3995,1780 C142.2@4065.31,1780 ; J302.3@7045,400 J302.3@7050,400
  Bottom Layer w25: C142.2@4063.5,1786.5 C129.2@4063.5,1830 ; C129.2@4065,1836.2 v1(4065,1890) ; U104.4@4065.43,1720 C142.2@4065.43,1779.84 ; J302.3@7045,395 J302.3@7045,400
  other v1: 3580,2025 3625,2025 3665,2025 3580,2060 3625,2060 3665,2060 3580,2095 3625,2095 3665,2095 3580,2130 3625,2130 3665,2130
AINP: R107.2 R109.1 R114.1 U100.2 | length 1494.5
  Signal Layer 1 w20: 3710,1410 3770,1410 3845,1335 3845,450 v1(3880,415)
  Bottom Layer w20: 3530,1460 3530,1430 v1@3557.76,1402.24 ; 3645,1575 3645,1600 3665,1620 R114.1@3861.38,1620 ; v1(3880,415) R107.2@3952.91,415 R107.2@3955,415
  other v1: 3520,1395 3560,1395 3600,1395 3520,1435 3560,1435 3600,1435 3520,1475 3560,1475 3600,1475 3520,1515 3560,1515
BB_BYPAS: D101.1 R104.2 U102.10 | length 2007.3
  Top Layer w25: U102.10@6396.42,2151.42 6396.42,2199.65 v1(6399.37,2202.6)
  Bottom Layer w25: D101.1@5780,3520 5560,3300 5560,2964.75 5828,2696.75 5828,2557.43 6084.41,2301.02 6300.94,2301.02 v1(6399.37,2202.6) ; D101.1@5785.53,3530 5785.53,3595.53 R104.2@5790,3600
BB_ONOFF: J301.60 R10.1 R139.1 | length 1478.7
  Top Layer w20: J301.60@5429.8,837.8 5429.96,837.95 5429.96,924.96 5442.5,937.5 ; 5443,937 5445,939 R10.1@5445,981.38 ; R139.1@6045.04,1814.8 6045.04,1804.96 v1(6080,1770)
  Signal Layer 2 w20: v1(5455,950) 5457.13,952.13 5457.13,1472.13 5755,1770 v1(6080,1770)
BBDRV: Q104.1 R125.2 R145.1 R147.2 | length 187.3
  Bottom Layer w29.53: Q104.1@6175.59,2635.59 R145.1@6238.58,2635.59 ; R147.2@6240.55,2684.8 6240.55,2615.91 6250.39,2606.06 6250.39,2586.38 6260.24,2576.54 R125.2@6260.24,2568.66
BBFET: J301.54 R8.1 R144.1 | length 3157
  Top Layer w20: 5210,905 R8.1@5210,1006.38 5210,1010.32 5211.81,1012.13 5232.13,1012.13 5340,1120 5770,1120 5825,1065 v1(6190,1065)
  Signal Layer 2 w20: v1(6190,1065) 6286.72,1065 6549.5,1327.78 6549.5,2253.53 6360.5,2442.53 6360.5,2542.22 6378.28,2560 6420,2560 v1(6520,2460)
  Bottom Layer w20: v1(6520,2460) 6520,2480 R144.1@6530,2490
Bulk_OK: J301.62
CLKIN: C307.1 J301.70 J301.74 R117.2 R317.1 | length 1927.6
  Top Layer w20: R317.1@5573.62,1021.38 C307.1@5573.62,980 5577.56,980 5587.28,970.28 J301.70@5587.28,837.8 J301.70@5587.44,837.64 ; R317.1@5575,1030 5575,1048.28 5586.72,1060 v1(5605,1060) 5605,1068.18 5623.82,1087 5671.18,1087 5711.37,1046.81 5711.37,961.15 5710,959.78 5710,955 5693.42,938.42 5664.89,938.42 5650.43,923.96 5650.43,837.95 J301.74@5650.28,837.8
  Signal Layer 3 w20: v1(4675,1610) 4675,1467.09 4677.09,1465 ; 4676.05,1463.95 5080,1060 v1(5605,1060)
  Bottom Layer w20: R117.2@4628.62,1620 4630.43,1618.19 4666.81,1618.19 v1(4675,1610)
DOUT: R118.2 R318.2 | length 1427.2
  Top Layer w20: v1(5635,1060) 5660,1060 5675,1045 R318.2@5675,1025
  Signal Layer 3 w20: 4704.09,1474.09 5091.18,1087 5616.18,1087 5635,1068.18 v1(5635,1060) ; 4705,1475 v1(4705,1610)
  Bottom Layer w20: R118.2@4628.62,1670 4675,1670 4705,1640 v1(4705,1610)
DRV_Relay: D105.1 R110.1 U102.15 | length 537.9
  Top Layer w25: v1(6133.62,2212.44) 6146.42,2199.65 U102.15@6146.42,2151.42
  Bottom Layer w20: R110.1@5750,2000 5850,2000 6062.44,2212.44 v1(6133.62,2212.44)
HFFET_H2A: J100.1 U2.4 | length 2309.4
  Top Layer w20: U2.4@4860,1740 4888,1712 v1(4888,1700) v1@4890,1700
  Signal Layer 2 w20: v1(4888,1700) 4888,1832.15 4893.05,1837.21 4893.05,2453.9 5038.81,2599.66 5038.81,3521.09 5240,3722.29 v1@5240,3810
  other v1: 5240.45,3808.16
HFFET_H3A: J100.5 U1.4 | length 2671.1
  Top Layer w20: v1(5061.29,1466.2) 5088.91,1493.82 U1.4@5090.91,1493.82
  Signal Layer 2 w20: 4942,1778.78 4942,1567.59 4944.18,1565.42 ; 4946.47,1563.09 5043.93,1465.62 v1@5059.77,1465.62 ; 4947.05,1778.78 4947.05,2431.54 5092.81,2577.29 5092.81,3495.63 5417.17,3820 v1(5440,3820) ; v1@5060.82,1466.67 v1(5061.29,1466.2)
  Signal Layer 3 w20: v1@5438.29,3818.88 v1@5440.96,3818.88
HFFET_L2B: J100.8 U4.4 | length 3002.9
  Top Layer w20: v1(4610,1755) 4617.81,1747.19 4666.78,1747.19 U4.4@4668,1748.41
  Signal Layer 2 w20: v1(4610,1755) 4832.25,1977.25 4832.25,2476.54 4979.81,2624.1 4979.81,3545.97 4981.48,3547.64 ; 4981.69,3547.42 5171.38,3737.1 5171.38,4050.07 5215.43,4094.13 5475.87,4094.13 v1(5540,4030)
HFFET_L3B: J100.4 U3.4 | length 2769.2
  Top Layer w20: v1(4898.39,1523.51) 4898.39,1502.93 U3.4@4899.7,1501.62
  Signal Layer 2 w20: 4898.35,1652.43 4898.35,1672.17 4915,1688.82 4915,1809.05 ; v1(4898.39,1523.51) 4898.39,1652.43 ; 4920.05,1809.05 4920.05,2442.72 5065.81,2588.47 5065.81,3506.82 5387.08,3828.09 5387.08,4010.58 5386.73,4010.93 ; v1@5338.31,4035.02 5364.19,4035.02 5387.5,4011.71
  other v1: 5340,4035
IAC_SNS1: C308.1 J301.14 R308.2 | length 207
  Top Layer w20: C308.1@4536.16,1006.27 R308.2@4577.62,1006.27 ; R308.2@4579.41,1003.08 J301.14@4579.41,837.8 J301.14@4579.57,837.64
IAC_SNS2: R302.2 R306.2 U300.1 | length 1062.3
  Top Layer w12: v1(4810,1235) v1@4812.56,1235 ; R302.2@4830,1252.44 R302.2@4830,1256.38 ; R302.2@4830,1260 4833.62,1256.38 4916.38,1256.38 4958.39,1298.39 4958.39,1338.39 U300.1@4960,1340 ; U300.1@4957.29,1346.5 U300.1@4958.39,1347.6
  Top Layer w20: v1(4810,1235) R302.2@4827.44,1252.44 ; v1(4953.07,516.3) 4953.49,515.88 R306.2@4973.7,515.88
  Signal Layer 2 w20: v1(4760.04,1087.41) 4760.04,1184.28 4761.52,1185.76 ; 4761.14,1186.14 v1(4810,1235)
  Signal Layer 3 w20: v1(4760.04,1087.41) 4760.04,1074.55 4893.87,940.72 4893.87,932.8 ; 4894.12,932.8 4894.12,711.19 4953.64,651.68 ; v1(4953.07,516.3) 4953.07,651.68
LFFET_HS: J301.49 R1.1 R136.1 | length 3367.8
  Top Layer w20: R1.1@5136.06,525 5136.72,525.65 5136.72,571.72 5146.34,581.34 J301.49@5146.34,703.94
  Signal Layer 3 w20: v1(3470,2570) 3454.46,2554.46 3454.46,2405.54 3480,2380 3690.4,2380 3749,2321.4 3749,1701 3860,1590 4389,1590 ; 4390,1589 4565,1414 4565,1355 4822.5,1097.5 4842.5,1097.5 5100,840 5100,730.97 5144.58,686.39 ; v1(5145,580) 5145,686.39
  Bottom Layer w20: R136.1@3433.62,2590 3450,2590 v1(3470,2570)
LFFET_LS: J301.51 R3.1 R134.1 | length 3493.1
  Top Layer w20: J301.51@5177.83,703.94 5177.83,582.83 v1(5175,580) 5180,575 5180,525.75 R3.1@5178.19,525.75
  Signal Layer 3 w20: v1(3690,2540) 3650,2500 3500,2500 3481.46,2481.46 3481.46,2420 3491.46,2410 3698.59,2410 3776,2332.59 3776,1715.82 3874.82,1617 4399.82,1617 ; 4401.18,1616 4594.09,1423.09 4594.09,1364.09 4833.68,1124.5 4853.68,1124.5 5127,851.18 5127,850 ; 5129,750 5129,850 ; 5130,750 5175,705 v1(5175,580)
  Bottom Layer w20: R134.1@3653.62,2540 v1(3690,2540)
Line: C106.2 C109.2 C110.2 C113.2 C115.1 L102.2 Q100.2 Q100.3-4-5-6-7-8 Q103.9 R112.1 U101.6 | length 3032.7
  Top Layer w20: v1(3210,2460) 3260,2460 3370,2570 v1(3370,3650)
  Top Layer w50: C109.2@2290,3442.36 2617.36,3115 2895,3115
  Top Layer w100: L102.2@3210.63,2683.07 3210.63,3240.63
  Bottom Layer w20: C115.1@3155.51,2468.98 3164.49,2460 v1(3210,2460) 3232.91,2437.09 U101.6@3252.95,2437.09 ; Q100.2@3240,3670 3240,3630 3350,3630 v1(3370,3650) R112.1@3370,3680
  Bottom Layer w29.53: 3130,2440 U101.6@3260,2440
  other v1: 2970,3380 3010,3380 3050,3380 3090,3380 3130,3380 3170,3380 3210,3380 2970,3420 3010,3420 3050,3420 3090,3420 3130,3420 3170,3420 3210,3420 2970,3460 3010,3460 3050,3460 3090,3460 3130,3460 3170,3460 3210,3460 2970,3500 3010,3500 3050,3500 3090,3500 3130,3500 3170,3500 3210,3500
NetC2_1: C2.1 R11.1 R16.2 U302.6 | length 146.1
  Bottom Layer w25: R16.2@4436.87,1180 R11.1@4486.38,1180 C2.1@4486.38,1219.31 ; U302.6@4485,1122.28 4485.69,1122.97 R11.1@4485.69,1179.31
NetC2_2: C2.2 R11.2 R14.2 U302.7 | length 141.1
  Bottom Layer w25: C2.2@4533.62,1219.31 R11.2@4533.62,1180 4580.93,1180 R14.2@4582.19,1178.74 ; U302.7@4535,1122.28 R11.2@4535,1175
NetC3_1: C3.1 R18.2 R19.2 U302.5 | length 154.6
  Bottom Layer w25: R18.2@4280,1125 4319.31,1125 4320,1124.31 R19.2@4320,1123.62 ; R19.2@4320.69,1123.62 C3.1@4365,1123.62 ; C3.1@4365.69,1122.28 U302.5@4435,1122.28
NetC6_1: C6.1 J301.23 R12.1 | length 250.7
  Top Layer w20: J301.23@4736.89,703.94 4737.05,703.78 4737.05,617.77 4770.22,584.6 4801.14,584.6 4815.51,570.23 C6.1@4815.51,549.27 ; C6.1@4817.32,544.23 4859.27,544.23 4860.71,545.68 R12.1@4860.71,547.09
NetC100_1: C100.1 D101.2 Q102.1 R100.2 R104.1 | length 254
  Top Layer w29.53: Q102.1@5928.5,3581.5 C100.1@5928.5,3700
  Bottom Layer w29.53: R104.1@5860,3600 v1(5930,3600) ; D101.2@5914.47,3530 5914.47,3595.53
NetC101_2: C101.2 D105.2 Q101.1 R110.2 R111.1 | length 689.6
  Top Layer w29.53: Q101.1@5470,1990 5470,1940 5510,1900 v1(5560,1900)
  Bottom Layer w25: v1(5560,1900) 5610,1900 R111.1@5620,1890 ; R111.1@5618.03,1898.27 5625.91,1890.39 5832.6,1890.39 D105.2@5840.47,1882.52
  Bottom Layer w50: R111.1@5620,1890 5770,1890 5790.77,1869.23 D105.2@5851.3,1869.23
NetC102_1: C102.1 L150.4 R156.1 R157.1 R158.1 U100.1 | length 1321
  Bottom Layer w20: 3310,1280 3320,1270 ; 3337.76,1252.24 3320,1270 ; 3352.24,1302.24 3320,1270
  Bottom Layer w50: R156.1@2737.09,1760 2800,1760 ; R156.1@2737.09,1780 R158.1@2737.09,2030 R157.1@2737.09,2130 ; 2800,1780 2980,1600 3150,1600 3310,1440 3310,1280 3310,1267.64
  other v1: 3515,1140 3555,1140 3595,1140 3515,1175 3555,1175 3595,1175 3515,1215 3555,1215 3595,1215 3515,1255 3555,1255 3595,1255
NetC103_1: C103.1 C106.1 D103.1 D103.3 D107.4 L102.1 L103.1 | length 1878.2
  Signal Layer 1 w50: C103.1@2600,3449.25 2600,2780 2807.79,2572.21 3351.44,2572.21 3404.27,2625.04 ; 3385,2605.21 3472.01,2692.22 3592.22,2692.22 L102.1@3630,2730
  other v1: 3740,2720 3790,2720 3840,2720 3740,2760 3790,2760 3840,2760 3740,2800 3790,2800 3840,2800 3740,2840 3790,2840 3840,2840 3740,2880 3790,2880 3840,2880
NetC105_2: C105.2 C108.2 L102.3 L150.3 R103.2 R150.2 R151.2 R152.2 | length 3315.1
  Top Layer w50: C108.2@2117.64,2130 2120,2130 2265,1985
  Top Layer w100: L150.3@2263.46,1897.17 2263.46,1983.46 2265,1985 2450,2170 2820,2170 ; 3090,2070 L102.3@3210,2190
  Signal Layer 2 w20: C105.2@3082.09,1790 3597.72,1790 3842.21,1545.51 3842.21,638.66 3864,616.87 v1@3914.36,616.87
  Bottom Layer w20: v1(3915.71,616.87) 3940.15,616.87 R103.2@3940.92,617.63
  Bottom Layer w50: R150.2@2222.91,1780 R152.2@2222.91,2030 R151.2@2222.91,2122.91
NetC110_1: C110.1 C113.1 C115.2 D109.1 U101.8 | length 580.3
  Bottom Layer w20: D109.1@2929.13,2530 2936.22,2537.09 U101.8@3252.95,2537.09
  Bottom Layer w39.37: D109.1@2900,2530 2929.13,2530 C115.2@3153.54,2530
NetC117_1: C117.1 R136.2 U101.2 | length 236.6
  Bottom Layer w20: R136.2@3390,2580 3390,2510 3412.91,2487.09 U101.2@3467.52,2487.09 C117.1@3547.09,2487.09
NetC118_1: C118.1 R134.2 U101.1 | length 188.1
  Bottom Layer w20: U101.1@3462.4,2537.09 U101.1@3467.52,2537.09 R134.2@3606.38,2537.09 ; C118.1@3606.38,2493.62 R134.2@3606.38,2537.09 ; R134.2@3607.09,2537.09 R134.2@3606.38,2537.09
NetC124_1: C124.1 R137.2 U102.1 | length 117.9
  Top Layer w20: R137.2@6096.42,1860.28 U102.1@6096.42,1934.88 ; R137.2@6100.16,1862.05 C124.1@6143.46,1862.05
NetC125_1: C125.1 R139.2 U102.2 | length 333.5
  Top Layer w20: R139.2@6045.04,1862.05 6045.04,1878.24 6047.5,1880.7 6047.5,1947.5 6067.61,1967.61 6067.61,1968.31 6078.74,1979.44 6079.44,1979.44 6086.06,1986.06 6133.62,1986.06 6146.42,1973.27 U102.2@6146.42,1934.88 6146.42,1914.21 C125.1@6192.68,1867.95 ; C125.1@6197.6,1861.06 C125.1@6197.6,1863.03
NetC132_1: C132.1 R143.2 U102.5 | length 137.1
  Top Layer w20: U102.5@6296.42,1934.88 6296.42,1911.85 R143.2@6330.47,1877.8
  Top Layer w25: R143.2@6332.44,1865.98 C132.1@6398.39,1865.98
NetC135_1: C135.1 R114.2 U104.2 | length 151.4
  Bottom Layer w25: R114.2@3908.62,1620 C135.1@3970,1620 ; C135.1@3975.69,1620.69 4064.74,1620.69 U104.2@4065.43,1620
NetC135_2: C135.2 R119.2 U104.3 | length 151.1
  Bottom Layer w25: R119.2@3908.62,1670 C135.2@3974.31,1670 ; C135.2@3980,1670 U104.3@4065.43,1670
NetC136_1: C136.1 R144.2 U106.6 | length 94.4
  Bottom Layer w25: U106.6@6471.85,2600.16 C136.1@6519.84,2600.16 ; R144.2@6530,2550 C136.1@6530,2596.38
NetC146_1: C146.1 R117.1 U104.7 | length 121.9
  Bottom Layer w20: U104.7@4510,1620 R117.1@4581.38,1620 4581.38,1571.38 C146.1@4580,1570
NetC147_1: C147.1 R118.1 U104.6 | length 108.5
  Bottom Layer w25: U104.6@4517.5,1670 R118.1@4580,1670 ; R118.1@4580,1675 4580,1719.31 4580.69,1720 C147.1@4581.38,1720
NetC150_1: C150.1 R121.1 R126.2 U107.6 | length 217.2
  Top Layer w10: v1(6270,290) 6270,290.48 6280,300.48 U107.6@6280,325.2
  Bottom Layer w20: R126.2@6213.62,280 6270,280 ; v1(6270,290) 6270,280 ; C150.1@6293.62,230 6293.62,276.38 6290,280 ; R121.1@6330,280 R121.1@6326.38,280 6290,280 ; 6270,280 6290,280
NetC300_2: C300.2 J301.17 R300.2 | length 200.7
  Top Layer w20: C300.2@4639.16,543.18 4681.58,543.18 4681.64,543.24 R300.2@4681.64,545.16 ; C300.2@4642.4,547.7 J301.17@4642.4,703.94
NetC301_1: C301.1 J301.37 R306.1 | length 191.3
  Top Layer w20: J301.37@4957.36,703.94 4957.36,586.32 R306.1@4976.94,566.75 ; R306.1@4976.2,563.55 5019.97,563.55 5020.66,564.25 C301.1@5020.66,565.5
NetC304_1: C304.1 DACA.1 J301.9 | length 489.8
  Top Layer w12: C304.1@4400,543.62 4400,547.56 4457.44,605 4497.83,605 4515,622.17 4515,625
  Top Layer w20: DACA.1@4205,305 4205,375 4367.87,537.87 4398.19,537.87 4400,539.68 C304.1@4400,543.62
NetC305_1: C305.1 DACB.1 J301.11 | length 465.4
  Top Layer w12: C305.1@4465,545 4465.43,545 4510.25,589.81 4534.81,589.81 4545,600 4545,625 ; J301.11@4544.07,700.09 J301.11@4547.91,703.94
  Top Layer w20: DACB.1@4355,310 4365,310 4498.63,443.63 4498.63,521.37 4475,545 C305.1@4465.43,545 ; C305.1@4453.62,545 C305.1@4455,543.62 4456.38,545 C305.1@4465,545
NetC306_1: C306.1 J301.40 R309.2 | length 211.9
  Top Layer w20: J301.40@4988.86,837.8 R309.2@4988.86,1005.21 ; R309.2@4989.56,1005.84 C306.1@5034.05,1005.82
NetC309_1: C309.1 J301.68 J301.72 R318.1 | length 306
  Top Layer w20: J301.68@5555,830 5555,812.57 5570.4,797.18 5604.17,797.18 5618.62,811.63 5618.62,837.64 J301.72@5618.78,837.8 5618.78,971.34 C309.1@5627.44,980 ; R318.1@5630,1020 5631.38,1018.62 C309.1@5631.38,980
NetD1_2: D1.2 R2.1 | length 47.8
  Top Layer w20: R2.1@5792.24,505 D1.2@5840,505
NetD106_1: D106.1 D106.3 L100.1 Q104.2
NetD109_2: D109.2 R132.1 | length 79.6
  Bottom Layer w29.53: D109.2@2782.13,2527.87 2782.13,2475.61 2790,2467.74 R132.1@2790,2451.5
NetDEBUG_1: DEBUG.1 J301.57 | length 401.7
  Top Layer w20: J301.57@5398.31,703.94 5398.46,703.78 5398.46,311.54 DEBUG.1@5405,305
NetF150_1: F150.1 J102.1 Line.1 | length 575.8
  Top Layer w50: Line.1@1804.42,1382.71 1806.68,1382.71 1973.74,1215.64 F150.1@1973.74,1195.66
  Top Layer w100: 1970.61,1159.39 2010,1120 ; 2010,1090 2010,1120 ; J102.1@2213.58,1052.48 2212.63,1053.44 2076.56,1053.44 2010,1120
NetF150_2: F150.2 L150.2 RV150.1 | length 442.1
  Top Layer w100: L150.2@2263.46,1542.83 2268.44,1537.86 2268.44,1331.56 F150.2@2270,1330 2440,1330 RV150.1@2480,1370
NetH2A_1: H2A.1 J301.53 R4.2 U2.2 | length 2484.7
  Top Layer w20: U2.2@4760,1785 v1(4790,1785) ; J301.53@5209.33,703.94 5209.33,580.67 v1(5210,580) 5210,568.28 5223.19,555.1 5223.19,521.81 R4.2@5225,520
  Signal Layer 2 w20: H2A.1@4655,300 4803,448 5186.87,448 5287.22,548.35 5287.22,616.63 5265.11,638.74 5210,638.74 ; v1(4790,1785) 4790,1401.74 4949.89,1241.85 ; 4949.48,1241.44 4949.48,1018.2 4973,994.68 ; 4974.9,991.72 5208.42,758.19 ; 5209.85,638.74 5210,638.74 ; v1(5210,580) 5210,638.74 ; 5210,758.19 5210,638.74
NetH3A_1: H3A.1 J301.50 R7.1 U1.2 | length 2277
  Top Layer w20: v1(4936.58,1534.8) 4978.44,1534.8 U1.2@4979.12,1535.48 ; R7.1@5120,1005 5121.81,1003.19 5121.81,975.94 5146.34,951.42 J301.50@5146.34,837.8
  Signal Layer 2 w20: H3A.1@4805,300 4862,243 5293.97,243 ; v1(4936.58,1534.8) 5127,1344.38 5127,982.99 v1@5120.4,976.39 ; 5127.25,1015.76 5165.6,1015.76 5341.82,839.54 5341.82,291.32 5293.97,243.47
  other v1: 5122.6,977.59
NetJ102_2: J102.2 L150.1 Neutral.1 RV150.2 | length 836.5
  Top Layer w100: L150.1@2696.54,1542.83 2709.53,1529.84 2709.53,1340.47 RV150.2@2770,1280 ; L150.1@2700,1540 L150.1@2709.53,1530.47 ; RV150.2@2767.64,1276.69 3003.31,1276.69 Neutral.1@3040,1240 3030,1240 3030,1161.59 2922.24,1053.83 J102.2@2922.24,1052.48
NetJ301_52: J301.52 L3B.1 R6.1 U3.2 | length 2008.5
  Top Layer w20: U3.2@4811.25,1536.11 4812.68,1534.69 v1(4851.14,1534.69) ; R6.1@5165,1005 5165,1002.44 5177.83,989.61 J301.52@5177.83,837.8
  Signal Layer 2 w20: v1(4851.14,1534.69) 4851.14,1512.08 5029.13,1334.09 5029.13,1030 ; L3B.1@4945.79,300.99 4945.79,303.44 5029.3,386.96 5247.9,386.96 ; 5029.61,1030 5029.61,1027.21 5125.81,931.01 5212.16,931.01 5314.11,829.07 5314.11,627.93 5314.22,627.81 5314.22,445.06 5313.28,444.12 ; 5176.45,931.95 5177.47,932.97 v1(5177.47,965.7) ; 5247.9,387.19 5256.63,387.19 5313.42,443.98
NetJ301_55: J301.55 L2B.1 R5.2 U4.2 | length 2300.2
  Top Layer w20: U4.2@4564.25,1784.59 4565,1785.34 v1@4599.36,1785.34 ; L2B.1@5105,305 L2B.1@5110,305 ; J301.55@5240.83,703.94 5240.83,589.17 v1(5250,580) 5268.19,561.81 5268.19,521.81 R5.2@5270,520
  Signal Layer 2 w20: v1(4600,1785) 4580.61,1765.61 4580.61,1546.25 4881.78,1245.09 4881.78,644.86 4995.06,531.57 5151.18,531.57 ; 5151.18,531.3 5231.98,531.3 5250.23,549.54 v1@5250.23,577.62
  Bottom Layer w20: L2B.1@5105,300 5105,375.18 5250.47,520.65 v1@5250.47,579.59
NetJ301_59: J301.59 P1.1 | length 453.7
  Top Layer w20: J301.59@5429.8,703.94 5429.8,425.2 5550,305 P1.1@5550,300
NetJ301_64: J301.64 R317.2 | length 203.6
  Top Layer w20: J301.64@5492.8,837.8 5492.8,998.02 5517.97,1023.19 5523.19,1023.19 R317.2@5525,1025
NetJ301_69: J301.69 P2.1 | length 451.8
  Top Layer w20: J301.69@5587.28,703.94 5587.28,532.13 5705,414.42 5705,315 P2.1@5695,305
NetJ301_79: J301.79 R2.2 | length 194
  Top Layer w20: J301.79@5744.76,703.94 5744.76,510.24 R2.2@5745,510
NetQ100_1: Q100.1 R108.2 R112.2 | length 185
  Bottom Layer w25: Q100.1@3295.35,3699.37 3295.35,3725.35 3330,3760 R108.2@3440,3760
NetQ103_1: Q103.1 R116.2 R124.2 | length 165.4
  Bottom Layer w20: Q103.1@3400.63,3525.35 3465.35,3525.35 3480,3540 R116.2@3560,3540
NetR101_2: R101.2 R102.1 | length 83.6
  Bottom Layer w25: R102.1@4268.3,614.54 4348.13,614.54 R101.2@4350.83,617.23
NetR102_2: R102.2 R103.1 | length 82.5
  Bottom Layer w25: R103.1@4068.42,613.47 4068.96,614.01 4148.23,614.01 R102.2@4149.99,615.77
NetR105_2: R105.2 R106.1 | length 90
  Bottom Layer w20: R106.1@4265,420 4347.91,420 R105.2@4352.91,415
NetR106_2: R106.2 R107.1 | length 77.9
  Bottom Layer w20: R107.1@4075,415 R106.2@4152.91,415
NetR122_1: R122.1 R123.2 U107.7 | length 125.3
  Top Layer w12: R122.1@6240,260 R122.1@6243.62,260 R123.2@6300,260 6299.84,260.16 6299.84,325.04 U107.7@6299.69,325.2
NetR145_2: R145.2 U106.2 | length 62
  Bottom Layer w25: R145.2@6301.57,2637.56 U106.2@6363.58,2637.56
NetR147_1: R147.1 U106.3 | length 62.3
  Bottom Layer w25: R147.1@6309.45,2694.65 6343.9,2694.65 U106.3@6363.58,2674.96
NetR150_1: R150.1 R153.2 | length 72.9
  Bottom Layer w50: R150.1@2337.09,1760 R153.2@2410,1760
NetR151_1: R151.1 R154.2 | length 72.9
  Bottom Layer w50: R151.1@2337.09,2130 R154.2@2410,2130
NetR152_1: R152.1 R155.2 | length 72.9
  Bottom Layer w50: R152.1@2337.09,2030 R155.2@2410,2030
NetR153_1: R153.1 R156.2 | length 62.9
  Bottom Layer w50: R153.1@2537.09,1760 R156.2@2600,1760
NetR154_1: R154.1 R157.2 | length 82.9
  Bottom Layer w50: R154.1@2537.09,2130 R157.2@2620,2130
NetR155_1: R155.1 R158.2 | length 72.9
  Bottom Layer w50: R155.1@2537.09,2030 R158.2@2610,2030
NetR302_1: R302.1 R305.2 U300.2 | length 268.2
  Top Layer w12: R302.1@4835,1295 4840.98,1289.02 4905.89,1289.02 4932.8,1315.93 U300.2@4932.8,1347.6 4933.89,1348.69 4933.89,1379.08 4950,1395.19 4984.81,1395.19 R305.2@5010,1370
NetR303_2: R303.2 R304.2 U300.3 | length 182.6
  Top Layer w12: R303.2@4785,1310 4785,1312.56 4818.87,1346.43 4818.87,1349.19 4824.69,1355 R304.2@4828.62,1355 R304.2@4829.76,1355 ; R304.2@4835,1345 4871.98,1308.02 4898.02,1308.02 4905,1315 U300.3@4905,1340 ; U300.3@4906.11,1348.69 U300.3@4907.2,1347.6
  Top Layer w20: R303.2@4780,1303.62 R303.2@4780,1305
NetR308_1: R308.1 R311.2 U302.1 | length 226.8
  Top Layer w12: R308.1@4583.43,1050.67 4583.43,1046.7 4586.34,1043.8 4602.37,1043.8 4607.09,1039.08 v1(4607.09,960.62)
  Bottom Layer w20: U302.1@4585,907.72 4585,852.56 4596.66,840.9 R311.2@4596.66,840.05 ; U302.1@4585,925 4585.63,925.63 4586.18,925.63 4607.09,946.54 v1(4607.09,960.62)
NetR311_1: R311.1 R312.1 U302.2 | length 138.6
  Bottom Layer w20: R312.1@4535,842.53 U302.2@4535,900 ; R312.1@4538.74,842.53 4575.39,805.87 4584.44,805.87 4595,795.32 R311.1@4595,791.38 R311.1@4595,790
NetR341_1: R341.1 R353.2 U300.6 | length 202.2
  Top Layer w12: R341.1@4900,1110 4900.32,1110 4907.2,1116.89 U300.6@4907.2,1172.4 4908.3,1173.5 4908.3,1203.3 4921.38,1216.38 5004.19,1216.38 5005,1217.19 R353.2@5005,1220
NetR347_2: R347.2 R348.1 U300.5 | length 108.2
  Top Layer w20: R347.2@4780,1156.38 4828.19,1156.38 4830,1158.19 R348.1@4830,1160 ; R348.1@4830,1156.38 4866.38,1156.38 U300.5@4880,1170
NetR350_1: R350.1 R351.2 | length 80.7
  Bottom Layer w50: R351.2@5940.39,981.26 R350.1@6021.1,981.26
NetR351_1: R351.1 R352.2 | length 70.9
  Bottom Layer w50: R352.2@5743.54,981.26 R351.1@5814.41,981.26
NetR354_1: R354.1 R356.2 | length 61
  Bottom Layer w50: R356.2@5940.39,819.29 R354.1@6001.42,819.29
NetR356_1: R356.1 R357.2 | length 70.9
  Bottom Layer w50: R357.2@5743.54,819.29 R356.1@5814.41,819.29
PE: C102.2 C103.2 C108.1 C109.1 J102.3 pad.1@2000,4200 pad.1@3650,600 | length 6672.8
  Top Layer w50: 1650,2130 C108.1@1822.36,2130 ; 1657.64,3737.64 C109.1@2290,3737.64 ; 2570,730 2620,680 3127.78,680 3310,862.22
  Top Layer w100: pad.1@1990,4200 1640,3850 1640,670 1730,580 2430,580 2567.91,717.91 J102.3@2567.91,1052.48
PGND: C1.1 C4.2 C5.1 C6.2 C104.1 C107.1 C111.2 C112.2 C114.1 C120.1 C124.2 C125.2 C126.1 C127.2 C128.2 C132.2 C133.2 C136.2 C137.2 C138.2 C139.2 C144.2 C145.2 C146.2 C147.2 C148.2 C149.2 C150.2 C300.1 C301.2 C304.2 C305.2 C306.2 C307.2 C308.2 C309.2 C313.2 C314.2 C315.2 C322.2 C324.2 C328.2 C329.2 C336.1 C337.1 C338.1 D1.1 J100.2 J100.3 J100.11 J100.12 J301.7 J301.10 J301.22 J301.29 J301.35 J301.38 J301.46 J301.47 J301.65 J301.83 J301.97 J301.111 J303.3 J303.6 PGND.1 PGND.2 Q104.3 R1.2 R3.2 R4.1 R5.1 R6.2 R7.2 R8.2 R9.2 R10.2 R113.1 R123.1 R125.1 R126.1 R143.1 R305.1 R328.1 R329.1 R353.1 R355.1 R358.1 RT301.1 U1.1 U1.3 U2.1 U2.3 U3.1 U3.3 U4.1 U4.3 U100.3 U100.4 U100.5 U100.7 U102.4 U104.5 U105.2 U106.4 U106.5 U107.4 U300.4 U302.4 U307.2 | length 24194.6
  Top Layer w12: v1@4715.91,1026.4 4719.99,1026.4 4730.92,1037.32 4745,1037.32 RT301.1@4745.89,1038.21
  Top Layer w20: C304.2@4400,496.38 4401.38,495 C305.2@4450,495 ; J301.7@4484.92,703.94 4484.92,754.92 v1(4500,770) 4516.42,786.42 J301.10@4516.42,837.8 ; C314.2@4548.73,495.28 R329.1@4591.81,495.28 ; R329.1@4593.62,495.61 4635.64,495.61 C300.1@4636.95,496.91 ; v1@4705.09,933.8 4705.24,933.66 4705.24,837.95 J301.22@4705.39,837.8 ; C313.2@4727.3,496.91 R328.1@4771.36,496.91 ; R328.1@4773.17,497.23 4773.29,497.11 4816.99,497.11 C6.2@4818.05,498.18 ; C322.2@4827.81,1053.2 4850.59,1053.2 4867.15,1053.2 C329.2@4867.97,1054.02 ; J301.29@4831.38,703.94 4831.54,704.09 4831.54,736.54 v1(4840,745) ; v1(4850.59,1040.08) 4850.59,1052.97 ; R358.1@4921.07,1047.62 4942.55,1047.62 4950,1040.16 v1(4950,950) 4957.36,942.64 J301.38@4957.36,837.8 4957.52,837.64 4957.52,787.52 4925.87,755.87 J301.35@4925.87,703.94 ; R353.1@5010,1263.62 5010,1315 5045,1315 5080,1350 v1(5960,1350) ; C301.2@5025.48,518.07 5028.26,518.07 5080,569.8 v1(5080,570) 5114.84,604.84 J301.47@5114.84,703.94 5114.69,704.09 5114.69,735.32 5083.5,766.5 ; v1@5073,765 5082.01,765 5083.5,766.5 ; J301.46@5083.35,837.8 5083.5,837.64 5083.5,766.5 ; J301.65@5524.29,703.94 5524.29,486.94 5555,456.24 PGND.1@5555,440 ; v1@5807.23,610.18 J301.83@5807.76,703.94 ; PGND.1@5958.52,298.41 5958.52,276.48 PGND.1@5965,270 ; v1(6015,590) 6028.07,603.07 6028.07,703.78 J301.97@6028.23,703.94 ; v1(6140,1770) C124.2@6140,1810 ; v1(6190,570) 6200.77,570 6248.54,617.77 6248.54,703.78 J301.111@6248.7,703.94
  Top Layer w25: v1(4508.32,1053.58) 4531.97,1053.58 C308.2@4533.63,1055.24 ; U4.1@4565,1825 4565,1855 4605,1895 C1.1@4653.5,1895 ; U4.3@4565.87,1747.6 4522.4,1747.6 v1(4520,1750) v1(4520,1805) 4536.71,1821.71 4565.18,1821.71 U4.1@4565.87,1822.4 ; C328.2@4635.72,1054.38 R355.1@4676.77,1054.38 ; 4658.54,1056.07 v1(4658.54,1080.14) ; 4740,1520 4761.71,1498.29 4800.18,1498.29 U3.3@4800.87,1497.6 ; 4740,1525 4740,1557.76 4754.64,1572.4 U3.1@4800.87,1572.4 ; U2.1@4750,1825 v1(4750,1840) ; U2.3@4750.87,1747.6 4750.18,1748.29 4729.68,1748.29 4711.68,1766.29 4711.68,1803.71 4729.68,1821.71 4750.18,1821.71 U2.1@4750.87,1822.4 ; U3.1@4805,1575 4865,1635 C5.1@4908.5,1635 ; v1(4865,1370) 4868.85,1370 U300.4@4878.85,1360 ; C329.2@4873.25,1053.37 R358.1@4915.6,1053.37 ; U1.3@4990.87,1497.6 4991.56,1498.29 5023.71,1498.29 ; U1.1@4991.56,1571.71 5030.25,1571.71 5054.83,1547.13 5054.83,1522.69 5030.32,1498.18 5023.71,1498.18 ; C306.2@5035.01,1053.03 5070.3,1053.03 5070,1052.73 v1(5070,1025) ; C324.2@5053.62,1170 v1(5100,1170) ; 5070.34,1053.03 5116.2,1053.03 R7.2@5117.11,1052.12 ; v1(5110,475) 5134.31,475 5135,474.31 R1.2@5135,472.76 R3.2@5180,472.76 R4.1@5225,472.76 R5.1@5269.31,472.76 ; R7.2@5120,1053.62 R6.2@5165,1053.62 R8.2@5209.31,1053.62 ; R9.2@5400,1028.62 5438.62,1028.62 R10.2@5440,1030 ; v1(5525,955) C307.2@5525,980 ; v1(5680,970) C309.2@5680,975 ; D1.1@5931.34,505 5931.34,506.97 6014.37,590 v1(6015,590) ; C128.2@6115,350 6139.69,350 C149.2@6160,370.31 ; C124.2@6143.46,1814.8 C133.2@6237.95,1814.8 ; C133.2@6237.95,1812.83 6281.26,1812.83 ; U102.4@6246.42,1934.88 6246.42,1915.61 6281.26,1880.77 v1(6281.26,1877.8) 6281.26,1812.83 ; v1(6345,230) R123.1@6345,260 ; C132.2@6388.54,1812.83 6281.26,1812.83 ; v1(6430,2460) v1(6430,2630) ; C126.1@6557.09,487.09 C126.1@6560,490
  Top Layer w50: v1(5239.87,4035.13) 5281.74,4077 5701.36,4077 v1@5740.49,4037.87 ; v1@5339.21,3822.76 5393.97,3768 5698,3768 5730,3800 ; 5733.19,3801.18 5780.95,3800.9 ; v1(5740.88,4037.48) 5781.99,4037.48 5811.28,4008.19 ; 5782.09,3801.57 5811.38,3830.86 5811.38,3992.89 ; C127.2@6450,470 6505,470 C126.1@6525,490 ; 6510,1295 6510.35,1294.65 6815.35,1294.65 6950,1160 J303.6@6950,1110 ; C126.1@6572.91,487.09 C148.2@6690,487.09
  Signal Layer 1 w20: 6125,610 6165,570 v1(6190,570)
  Signal Layer 2 w20: 5511.13,970 5511.13,1449.76 5777.37,1716 6102.37,1716 6140,1753.63 v1(6140,1770)
  Signal Layer 2 w25: 5374.02,951.54 5374.02,1312.86 5070.67,1616.21 5062.55,1624.32 5062.55,2383.69 5208.31,2529.45 5208.31,2575.38 5208.31,3447.79 5441.43,3680.92 5599.52,3680.92 5718.6,3800 ; 5374.16,951.54 5374.16,745.84 5460,660 5580,660 PGND.1@5970,270 ; 5513.63,966.37 v1(5525,955) ; 5723.28,3799.77 5759.61,3799.77 6269.84,4310 6603.15,4310 PGND.1@6605.88,4312.72 ; v1(6075,1095) 6275,1095 6520,1340 6520,2241.31 6331,2430.31 6331,2554.44 6366.06,2589.5 6409.5,2589.5 6430,2610 v1(6430,2630) ; v1(6255,555) 6255,585 6215,625 5985,625 5760,850 5727.5,850 5572.63,1004.87 5572.63,1422.37 5804.75,1654.5 6128.53,1654.5 6176.43,1606.59 6253.57,1606.59 6301.04,1654.07 6301.04,1858.96 ; v1(6281.26,1877.8) 6282.2,1877.8 6300,1860 ; v1(6420,550) 6362,608 6362,1053.31 6611,1302.31 6611,2279 v1(6430,2460)
  Bottom Layer w20: 4112.24,1402.24 4130,1420 ; U105.2@4550,1404.13 U105.2@4550,1420 ; C336.1@4770,950 4740,920 4740,890 4770,860 4885,860 4892.9,867.9 4929,867.9 4940.82,879.73 4940.82,940.82 v1(4950,950) ; 4930,860 C337.1@4960,890 ; 5960,1320 v1(5960,1350) ; 6439.37,2637.56 U106.5@6471.85,2637.56 ; U106.5@6471.85,2639.53 U106.4@6471.85,2670.04 ; U106.5@6482.68,2639.53 C136.2@6525.98,2639.53
  Bottom Layer w25: v1(4355,905) 4357.72,907.72 U302.4@4435,907.72 ; C145.2@4420,1490 4423.8,1490 4425,1491.2 v1(4425,1515) 4445,1535 ; C138.2@4450,1380 4450,1425 4468.32,1443.32 4531.31,1443.32 4550,1424.63 U105.2@4550,1420 ; C144.2@4470,1535 4445,1535 ; U104.5@4493.88,1719.31 4444.64,1719.31 4430,1704.67 4430,1550 4445,1535 ; 4570,1050 4578.5,1058.5 C315.2@4650,1058.5 ; v1(4630,1550) C146.2@4630,1565 ; C147.2@4635,1720 4640,1720 v1(4655,1705) ; PGND.1@5970,270 6055,340 ; 6070,350 6250,350
  Bottom Layer w39.37: Q104.3@5950,2630 6141.26,2438.74 6260.24,2438.74 ; R125.1@6260.24,2505.67 6260.24,2438.74 ; C137.2@6455.12,2517.48 6455.12,2485.98 6407.87,2438.74 6260.24,2438.74
  Bottom Layer w50: v1(6420,550) 6680,550 6720,590 6720,800 6750,830 ; 6775,805 6777.48,802.52 7109.4,802.52 7147.48,840.6 7147.48,959.4 7109.4,997.48 7052.52,997.48 J303.3@7050,1000
  other v1: 6065,275 6090,275 6115,275 6065,300 6090,300 6115,300 6390,435 6495,450 6625,455 6390,460 5248.34,468.34 6625,485 4425,495 4570.94,496.32 4615.64,495.73 4750.61,497.51 6255,525 6285,525 6315,525 6285,555 6315,555 5807.23,609.98 4925.84,743.71 5070,765 4705.18,933.54 4716.31,1024.88 5422.42,1027.27 4717.87,1160.59 6720,1190 5800,1250 5830,1250 5860,1250 5890,1250 5920,1250 5950,1250 5980,1250 6010,1250 6040,1250 6070,1250 6100,1250 6130,1250 4130,1255 4095,1280 4420,1385 4075,1405 4445,1430 4075,1455 5045.87,1512.87 4740,1535 4445,1720 6500,2760 6470,2790 7190,2940 7190,2980 5748.69,3800.34 5338.31,3824.56
RELAY_CTRL: J301.58 R9.1 R137.1 | length 1738
  Top Layer w20: R9.1@5400,985 5398.46,983.46 5398.46,837.95 J301.58@5398.31,837.8 5398.46,837.64 5398.46,811.63 5430.09,780 v1(5440,780) ; R137.1@6094.25,1814.8 6110,1799.06 v1(6110,1770)
  Signal Layer 2 w20: v1(5440,780) 5440,851.18 5484.13,895.31 5484.13,1460.94 5766.18,1743 6091.18,1743 6110,1761.82 v1(6110,1770)
SCI_RX0: J301.76
SCI_TX0: J301.78
SWNODE: L103.2 TP103.1 TP104.1
  other v1: 3975,3965 4010,3965 4045,3965 4080,3965 4110,3965 3975,3990 4010,3990 4045,3990 4080,3990 4110,3990
TMP_PRI: C322.1 J301.28 R340.2 RT301.2 | length 220.8
  Top Layer w12: RT301.2@4745.89,1012.62 4746.78,1011.73 4780.29,1011.73 R340.2@4780.58,1011.45
  Top Layer w20: J301.28@4799.88,837.8 4799.88,999.2 4800.22,999.54 ; 4800.22,1005.83 C322.1@4823.97,1005.83
VBB: C104.2 C107.2 D106.2 Q102.9 R354.2 Vout.1 Vout.2 | length 3193.2
  Top Layer w50: Q102.9@6236.69,3424.02 Q102.9@6236.69,3470.83
  Bottom Layer w20: R354.2@6150,820 6250,820 7250,1820 7250,3100 7100,3250 Vout.1@7100,3390
  other v1: 6100,3240 6160,3240 6220,3240 6100,3270 6160,3270 6220,3270 6100,3300 6160,3300 6220,3300 6100,3330 6160,3330 6220,3330 6100,3360 6160,3360 6220,3360 6100,3390 6160,3390 6220,3390 6100,3420 6160,3420 6220,3420 6100,3450 6160,3450 6220,3450
VBB_FB: C329.1 J301.34 R357.1 R358.2 | length 940.1
  Top Layer w12: J301.34@4890.53,841.64 J301.34@4894.37,837.8
  Top Layer w15: C329.1@4873.02,993.29 4873.02,948.18 4892.03,929.18 4892.03,913.03 4895.72,909.34
  Top Layer w20: C329.1@4873.25,1006.12 R358.2@4908.78,1006.12 ; R358.2@4908.78,1004.05 4909.79,1003.05 v1(4909.79,983.65)
  Bottom Layer w20: v1(4909.79,983.65) 4965.9,983.65 5056.54,893 5578.62,893 5613.78,857.84 5613.78,840.86 R357.1@5622.22,832.43
Vbulk: C100.2 C101.1 C114.2 C120.2 C122.1 C131.2 J303.2 J303.5 L100.2 Q101.2 Q101.3-4-5-6-7-8 Q102.2 Q102.3-4-5-6-7-8 R100.1 R111.2 R350.2 RT100.1 U102.9 U102.14 | length 7696.7
  Top Layer w25: Q101.2@5521.89,2019.37 5521.89,1968.11 5540,1950 v1(5560,1950) ; Q102.2@5912.87,3522.44 5977.56,3522.44 5990,3534.88 C100.2@5990,3690 ; R100.1@5991.5,3640 C100.2@5991.5,3688.5 ; U102.14@6196.42,2151.42 6196.42,2285.08 6232.05,2320.71 6281.26,2320.71 6330.47,2271.5 6389.53,2271.5 6446.42,2214.61 U102.9@6446.42,2151.42 ; U102.9@6450,2140 6460,2130 6475.25,2130 7222,1383.25 7222,872 7185,835 6965,835 6950,850 J303.2@6950,900 J303.2@6950,910
  Top Layer w29.53: 6370,1620 6375.35,1620 6370,1625.35
  Top Layer w50: 6390,1540 6480,1540 6635.35,1384.65 6853.21,1384.65 7050,1187.86 J303.5@7050,1100
  Bottom Layer w20: C101.1@5670,1960 5670,2010 5704.2,2044.2 5844.2,2044.2 6041.97,2241.97 6170.04,2241.97 v1@6194.65,2217.36
  Bottom Layer w25: RT100.1@5359.21,2094.76 RT100.1@5359.21,2101 ; v1(5560,1950) C101.1@5670,1950 ; v1(5980,3520) 5946.48,3486.48 5791.74,3486.48 5592,3286.75 5592,2978 5860,2710 5860,2570.69 6097.66,2333.02 6326.98,2333.02 v1(6450,2210) ; R350.2@6160,990 6360,990 6602.5,1232.5 6602.5,1562.5 6485,1680 6435,1680 C114.2@6425,1690
  other v1: 5530,2100 5560,2100 5590,2100 5620,2100 5650,2100 5680,2100 5710,2100 5740,2100 6192.68,2212.44 5840,3240 5840,3270 5840,3300 5840,3330 5840,3360 5840,3390 5840,3420 5840,3450
Vbulk1: C121.2 D103.4 Q100.9 Q101.9 RT100.2 TP101.1 TP102.1
  other v1: 5240.44,2309.81 5280,2310 5240.44,2339.81 5280,2340 5240.44,2369.81 5280,2370 5240.44,2399.81 5280,2400 5240.44,2429.81 5280,2430 4380,3625 4415,3625 4445,3625 4475,3625 4505,3625 4380,3650 4415,3650 4445,3650 4475,3650 4505,3650 4380,3680 4415,3680 4445,3680 4475,3680 4505,3680 3010,3960 3050,3960 3090,3960 3130,3960 3170,3960 3210,3960 3250,3960 3010,4000 3050,4000 3090,4000 3130,4000 3170,4000 3210,4000 3250,4000 3010,4040 3050,4040 3090,4040 3130,4040 3170,4040 3210,4040 3250,4040 3010,4080 3050,4080 3090,4080 3130,4080 3170,4080 3210,4080 3250,4080
Vbulk_SNS: C328.1 J301.18 R352.1 R355.2 | length 1307.5
  Top Layer w20: C328.1@4632.82,1001.29 4642.4,991.7 J301.18@4642.4,837.8 ; C328.1@4635.72,1007.13 4679.97,1007.13 4680.12,1007.28 R355.2@4680.12,1007.51
  Bottom Layer w12: R352.1@5611.03,1007.47 R352.1@5627.4,991.1
  Bottom Layer w20: v1@4645.1,963.51 4709.32,963.51 4756.46,1010.65 4977.44,1010.65 4983.04,1005.05 ; 4982.86,1004.87 5067.73,920 5578.94,920 5630,971.06 R352.1@5630,980
  other v1: 4643.99,963.47
VFLY_SENSE: J100.7 R12.2 | length 4298.2
  Top Layer w20: R12.2@4861.08,496.99 4861.08,497.45 4862.89,499.26 v1@4893.17,499.26 ; v1(4893.17,498.89) 4963.26,428.8 5295.48,428.8 5324.51,457.83 v1@5324.51,1007.23
  Signal Layer 2 w20: v1@5026.77,1534.95 4971.54,1590.18 4971.54,1765.08 4974.05,1767.59 4974.05,2418.48 4976.7,2421.13 4976.7,2423 5119.81,2566.11 5119.81,3484.45 5404.77,3769.42 5489.42,3769.42 v1(5535,3815)
  Bottom Layer w20: 5017.67,1398.67 5324.22,1092.12 v1(5324.22,1007.77) ; 5018,1398.67 5018,1526.18 5025.33,1533.52 v1(5025.33,1534.91)
VMON: J302.1
ZCD: C117.2 C118.2 C119.2 C121.1 D107.1 D107.3 Q103.2 Q103.3-4-5-6-7-8 R113.2 R124.1 R303.1 R347.1 TP105.1 TP106.1 U101.4 | length 6741.6
  Top Layer w20: 4730,1330 4730,1290 4757.87,1262.13 4778.19,1262.13 4780,1260.32 R303.1@4780,1260 ; 4730,1335 4730,1360 4820,1450 5030,1450 5100,1380 v1(5960,1380) ; R347.1@4780,1203.62 R303.1@4780,1256.38
  Signal Layer 2 w20: v1@3440,2360 3440,2487 ; 3440,2477 3387,2530 3387,3407 3420,3440 v1(3490,3440)
  Signal Layer 3 w20: v1@3730,2480 3830,2380 3830,2115 3910,2035 4795,2035
  Bottom Layer w20: Q103.2@3400.63,3478.11 R124.1@3490,3478.11 ; v1(3437.99,2353.82) 3437.99,2379.41 3446.85,2388.27 3525.59,2388.27 C117.2@3564.96,2427.64 ; v1(3490,3440) R124.1@3490,3478.11 ; R124.1@3500,3470 3491.89,3478.11 R124.1@3490,3478.11 ; 3683.07,2486.69 3692.91,2486.69 ; 3712.6,2476.85 v1(3732.28,2476.85) ; v1(5950,1440) 5960,1430 v1(5960,1380)
  Bottom Layer w50: 4575,3285 5110,2750 ; 5110,2060 5114.54,2055.46 5114.54,2035.55 5150,2000.09 5169.91,2000.09 5740,1430 5960,1430 5980,1430 ; 5819.88,1424.65 5950,1424.65 ; 5980,1424.65 6107.28,1424.65 ; 6008.86,1430 6110,1430
  other v1: 5800,1440 5830,1440 5860,1440 5890,1440 5920,1440 5980,1440 3665,2470 3470,3230 3470,3260 3470,3290 3470,3320 3470,3350 3470,3380 3470,3410 4460,4100 4500,4100 4535,4100 4570,4100 4605,4100 4460,4135 4500,4135 4535,4135 4570,4135 4605,4135
ZCD_SNS: R309.1 R341.2 U300.7 | length 136.4
  Top Layer w12: R341.2@4932.8,1116.89 U300.7@4932.8,1172.4
  Top Layer w20: R341.2@4936.63,1109.76 4936.82,1109.76 4989.56,1057.02 R309.1@4989.56,1053.09 ; R341.2@4946.31,1109.11 R341.2@4948.45,1109.11
pads on no net: J100. J102.MH1 J102.MH2 J301.1 J301.2 J301.3 J301.4 J301.5 J301.6 J301.8 J301.13 J301.16 J301.19 J301.20 J301.24 J301.25 J301.26 J301.27 J301.30 J301.31 J301.32 J301.33 J301.36 J301.39 J301.41 J301.42 J301.43 J301.44 J301.45 J301.56 J301.61 J301.63 J301.66 J301.67 J301.71 J301.73 J301.75 J301.77 J301.80 J301.81 J301.82 J301.85 J301.86 J301.87 J301.88 J301.89 J301.90 J301.91 J301.92 J301.93 J301.94 J301.95 J301.96 J301.99 J301.100 J301.101 J301.102 J301.103 J301.104 J301.105 J301.106 J301.107 J301.108 J301.109 J301.110 J301.113 J301.114 J301.115 J301.116 J301.117 J301.118 J301.119 J301.120 J301.181 J301.182 J301.185 J301.186 RT301.1S RT301.2S U102.6 U102.7 U102.12 U102.13 U105.4 U107.2 U107.5
copper on no net:
  other v2: 6305.59,406.5 6344.96,406.5 6305.59,426.18 6344.96,426.18 6305.59,445.87 6344.96,445.87

## Polygon pours and split planes (outlines as drawn)
ZCD on Bottom Layer "BOTTOM_LAYER_ZCD_P511" (solid, pour order 511): 36 vertices, not listed, extent 3351.76,1400.29 6161.93,3739.46
NetC103_1 on Bottom Layer "BOTTOM_LAYER_NETC103_1_P508" (solid, pour order 508): 22 vertices, not listed, extent 3523.64,2405.29 4936.06,3182.32
SWNODE on Bottom Layer "BOTTOM_LAYER_SWNODE_P499" (solid, pour order 499): 3868.8,4083.19 3908.45,4122.83 3908.45,4123.55 4190.27,4123.55 4240,4073.82 4240,3979.4 4240.72,3978.68 4197.48,3935.43 3901.24,3935.43 3900.52,3934.71 3868.08,3967.14 3868.08,4083.07 3868.07,4083.08 3868.31,4083.31 3868.77,4083.31
PGND on Bottom Layer "PGND" (solid, remove dead copper, pour order 283): 31 vertices, not listed, extent 4035,190.44 6050.33,1490
PGND on Bottom Layer "PGND" (solid, remove dead copper, pour order 301): 17 vertices, not listed, extent 5930,210 6810,1240
PGND on Bottom Layer "PGND" (solid, remove dead copper, pour order 305): 7220,3000 6460,3000 6420,2960 6420,2780 6460,2740 6540,2740 6590,2690 6590,2430 6780,2240 7190,2240 7260,2310 7260,2960
PGND on Bottom Layer "PGND" (solid, remove dead copper, pour order 401): 6430,2710 6400,2680 6400,2530 6380,2510 6150,2510 5980,2680 5950,2680 5930,2660 5930,2590 6130,2390 6440,2390 6540,2490 6540,2690 6520,2710
Vbulk1 on Bottom Layer "BOTTOM_LAYER_VBULK1_P405" (solid, remove dead copper, pour order 405): 5060,3830 5050,3840 4390,3840 4340,3790 4340,3602.83 4362.28,3580.55 4650.55,3580.55 4800,3730 5060,3730
NetF150_1 on Bottom Layer "BOTTOM_LAYER_NETF150_1_P422" (solid, pour order 422): 1923.09,1279.48 2073.09,1279.48 2273.09,1079.48 2273.09,989.48 2193.09,909.48 1873.09,909.48 1823.09,959.48 1823.09,1179.48 1913.09,1269.48